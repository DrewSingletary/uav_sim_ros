Commit message: Kalman Filter for UAV Quadrotor

File: rviz/URDF/cast.urdf (robot description, URDF)
Before this commit: robot cast_flying_arena, 1 links, 0 joints
Links:
- link world: geometry visual mesh filename=package://uav_sim_ros/rviz/Meshes/Environment/cast_simple_2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 scale=1 1 1
